# IAR project msa_cc2430.ewp, settings and files
configuration CC2430DB Object (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\derivatives\chipcon\CC2430.i51
  ICC8051.CCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\CC2430DB; ..\..\..\..\..\Components\mac\include; ..\..\..\..\..\Components\mac\high_level; ..\..\..\..\..\Components\mac\low_level; ..\..\..\..\..\Components\mac\low_level\srf03; ..\..\..\..\..\Components\mac\low_level\srf03\single_chip; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\services\sdata; ..\..\..\..\..\Components\mt; ..\..\..\common\cc2430\
  ICC8051.CCDefines: CC2430DB; POWER_SAVING
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  XLINK.XclFile: lnk51ew_cc2430.xcl
configuration CC2430EB Object (8051, debug)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\derivatives\
  ICC8051.CCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\CC2430EB; ..\..\..\..\..\Components\mac\include; ..\..\..\..\..\Components\mac\high_level; ..\..\..\..\..\Components\mac\low_level; ..\..\..\..\..\Components\mac\low_level\srf03; ..\..\..\..\..\Components\mac\low_level\srf03\single_chip; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\services\sdata; ..\..\..\..\..\Components\mt; ..\..\..\common\cc2430\
  ICC8051.CCDefines: CC2430EB; POWER_SAVING; MAX_LCD_CHARS=16; LCD_HW; LCD_SD; ZAPP_P1; MSA_ROLE=0
  group Application
    ../../Application/: msa.c msa.h msa_Main.c msa_Osal.c
  group HAL/Common
    $EW_DIR$/../../../Texas Instruments/TI-MAC-1.0.1/Components/hal/common/: hal_assert.c hal_drivers.c
    $EW_DIR$/../../../Texas Instruments/TI-MAC-1.0.1/Components/hal/include/: hal_assert.h hal_defs.h hal_drivers.h
  group HAL/Drivers
    $EW_DIR$/../../../Texas Instruments/TI-MAC-1.0.1/Components/hal/include/: hal_adc.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/CC2430DB/Config
    $EW_DIR$/../../../Texas Instruments/TI-MAC-1.0.1/Components/hal/target/CC2430DB/: hal_board_cfg.h hal_target.c hal_target.h
  group HAL/Target/CC2430DB/Drivers
    $EW_DIR$/../../../Texas Instruments/TI-MAC-1.0.1/Components/hal/target/CC2430DB/: hal_adc.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_timer.c hal_uart.c
  group HAL/Target/CC2430DB/Includes
    $EW_DIR$/../../../Texas Instruments/TI-MAC-1.0.1/Components/hal/target/CC2430DB/: hal_mailbox.h hal_mcu.h hal_types.h
  group HAL/Target/CC2430EB/Config
    $EW_DIR$/../../../Texas Instruments/TI-MAC-1.0.1/Components/hal/target/CC2430EB/: hal_board_cfg.h hal_target.c hal_target.h
  group HAL/Target/CC2430EB/Drivers
    $EW_DIR$/../../../Texas Instruments/TI-MAC-1.0.1/Components/hal/target/CC2430EB/: hal_adc.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_timer.c hal_uart.c
  group HAL/Target/CC2430EB/Includes
    $EW_DIR$/../../../Texas Instruments/TI-MAC-1.0.1/Components/hal/target/CC2430EB/: hal_mailbox.h hal_mcu.h hal_types.h
  group MAC/High Level
    $EW_DIR$/../../../Texas Instruments/TI-MAC-1.0.1/Components/mac/high_level/: mac_cfg.c mac_high_level.h mac_pib.h mac_spec.h
  group MAC/High Level/Lib
    ../../../Libraries/cc2430/IAR/bin/Lib/: macLib_cc2430.lib
  group MAC/Include
    $EW_DIR$/../../../Texas Instruments/TI-MAC-1.0.1/Components/mac/include/: mac_api.h
  group MAC/Low Level/Common
    $EW_DIR$/../../../Texas Instruments/TI-MAC-1.0.1/Components/mac/low_level/srf03/: mac_assert.h mac_backoff_timer.c mac_backoff_timer.h mac_low_level.c mac_low_level.h mac_radio.c mac_radio.h mac_random.c mac_random.h mac_rx.c mac_rx.h mac_rx_onoff.c mac_rx_onoff.h mac_sleep.c mac_sleep.h mac_tx.c mac_tx.h
  group MAC/Low Level/System
    $EW_DIR$/../../../Texas Instruments/TI-MAC-1.0.1/Components/mac/low_level/srf03/single_chip/: mac_csp_tx.c mac_csp_tx.h mac_mcu.c mac_mcu.h mac_mem.c mac_mem.h mac_radio_defs.c mac_radio_defs.h
  group OSAL
    $EW_DIR$/../../../Texas Instruments/TI-MAC-1.0.1/Components/osal/common/: OSAL.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Tasks.c OSAL_Timers.c
  group Services
    $EW_DIR$/../../../Texas Instruments/TI-MAC-1.0.1/Components/services/saddr/: saddr.c
