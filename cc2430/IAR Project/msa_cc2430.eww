<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\msa_cc2430.ewp</path>
  </project>
</workspace>

